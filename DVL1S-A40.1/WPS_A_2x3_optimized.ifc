Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: WPS_A_2x3.IFC
Time: 2022-09-09T05:30:25
Written by: SwIFC
Made in: SolidWorks 2020 (Solibri IFC Optimizer)

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2.M22.03.00.00_B.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: 2.M22.03.00.00_B; Nomenclature: 2.M22.03.00.00_B; Part Number: 2.M22.03.00.00_B; Source: NOT_KNOWN

# IfcBuildingElementProxy: 9Aroub AM2.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: noži?ka stav?cí šroub AM2; Nomenclature: noži?ka stav?cí šroub AM2; Part Number: noži?ka stav?cí šroub AM2; Source: NOT_KNOWN

# IfcBuildingElementProxy: Cable Gland PG7-PG19 Body_PG16.step (6)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Cable Gland PG7-PG19 Body_PG16; Nomenclature: Cable Gland PG7-PG19 Body_PG16; Part Number: Cable Gland PG7-PG19 Body_PG16; Source: NOT_KNOWN

# IfcBuildingElementProxy: Cable Gland PG7-PG19 Gland Nut_PG16.step (6)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Cable Gland PG7-PG19 Gland Nut_PG16; Nomenclature: Cable Gland PG7-PG19 Gland Nut_PG16; Part Number: Cable Gland PG7-PG19 Gland Nut_PG16; Source: NOT_KNOWN

# IfcBuildingElementProxy: Cable Gland PG7-PG19 Sleeve_PG16.step (6)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Cable Gland PG7-PG19 Sleeve_PG16; Nomenclature: Cable Gland PG7-PG19 Sleeve_PG16; Part Number: Cable Gland PG7-PG19 Sleeve_PG16; Source: NOT_KNOWN

# IfcBuildingElementProxy: Cable Gland PG7-PG19 Washer_PG16.step (6)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Cable Gland PG7-PG19 Washer_PG16; Nomenclature: Cable Gland PG7-PG19 Washer_PG16; Part Number: Cable Gland PG7-PG19 Washer_PG16; Source: NOT_KNOWN

# IfcBuildingElementProxy: Cu trubka 28.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Cu trubka 28; Nomenclature: Cu trubka 28; Part Number: Cu trubka 28; Source: NOT_KNOWN

# IfcBuildingElementProxy: DDT A2.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: M10 MATICOVÝ NÝT A2; Nomenclature: M10 MATICOVÝ NÝT A2; Part Number: M10 MATICOVÝ NÝT A2; Source: NOT_KNOWN

# IfcBuildingElementProxy: DIN 3771_12x2.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: DIN 3771_12x2; Nomenclature: DIN 3771_12x2; Part Number: DIN 3771_12x2; Source: NOT_KNOWN

# IfcBuildingElementProxy: E1.step (8)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Al spojka plast-rohová; Nomenclature: Al spojka plast-rohová; Part Number: Al spojka plast-rohová; Source: NOT_KNOWN

# IfcBuildingElementProxy: FD.step (17)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: zámek celokovový; Nomenclature: zámek celokovový; Part Number: zámek celokovový; Source: NOT_KNOWN

# IfcBuildingElementProxy: PG21.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: PG21; Nomenclature: PG21; Part Number: PG21; Source: NOT_KNOWN

# IfcBuildingElementProxy: PRUCHODKA 38x2.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: PRUCHODKA 38x2; Nomenclature: PRUCHODKA 38x2; Part Number: PRUCHODKA 38x2; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 1-2.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 1; Nomenclature: Part 1; Part Number: Part 1; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 1-3.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.001; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 1; Nomenclature: Part 1; Part Number: Part 1; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 1-5.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.001; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 1; Nomenclature: Part 1; Part Number: Part 1; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 1-7.step (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.001; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 1; Nomenclature: Part 1; Part Number: Part 1; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 1-8.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 1; Nomenclature: Part 1; Part Number: Part 1; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 1-9.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 1; Nomenclature: Part 1; Part Number: Part 1; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 1.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 1; Nomenclature: Part 1; Part Number: Part 1; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 14.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 14; Nomenclature: Part 14; Part Number: Part 14; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 15.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 15; Nomenclature: Part 15; Part Number: Part 15; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 16.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 16; Nomenclature: Part 16; Part Number: Part 16; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 17.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 17; Nomenclature: Part 17; Part Number: Part 17; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 18.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 18; Nomenclature: Part 18; Part Number: Part 18; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 19.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 19; Nomenclature: Part 19; Part Number: Part 19; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 2-1.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 2; Nomenclature: Part 2; Part Number: Part 2; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 2-6.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 2; Nomenclature: Part 2; Part Number: Part 2; Source: NOT_KNOWN

# IfcBuildingElementProxy: Part 2.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: Part 2; Nomenclature: Part 2; Part Number: Part 2; Source: NOT_KNOWN

# IfcBuildingElementProxy: S1400-25-900-0.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: S1400-25-900; Nomenclature: S1400-25-900; Part Number: S1400-25-900; Source: NOT_KNOWN

# IfcBuildingElementProxy: S1400-25-900-4.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: S1400-25-900; Nomenclature: S1400-25-900; Part Number: S1400-25-900; Source: NOT_KNOWN

# IfcBuildingElementProxy: S1400-25-900.step (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Description: S1400-25-900; Nomenclature: S1400-25-900; Part Number: S1400-25-900; Source: NOT_KNOWN

# IfcElementAssembly: WPS_A_2x3
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.009; Source: NOT_KNOWN; Part Number: AQ22I; Nomenclature: AQ22I; Description: AQ22I; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F; Erstellt_am: 09.09.2022; Beschreibung: WPS A

# IfcElementAssembly: Zeichnungen_Mastertherm_WP_20210914.step
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.009; Source: NOT_KNOWN; Part Number: AQ22I; Nomenclature: AQ22I; Description: AQ22I
